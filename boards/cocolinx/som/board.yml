## boards/cocolinx/som/board.yml
```yaml
board:
  name: cocolinx_som
  full_name: nRF9151 SOM
  vendor: cocolinx
  socs:
  - name: nrf9151
    variants:
    - name: 'ns'
```
